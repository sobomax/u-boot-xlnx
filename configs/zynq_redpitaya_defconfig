## configs/zynq_redpitaya_defconfig
```kconfig
CONFIG_SPL=y
CONFIG_ARM=y
CONFIG_ZYNQ=y
CONFIG_TARGET_ZYNQ_REDPITAYA=y
CONFIG_OF_CONTROL=n
CONFIG_DEFAULT_DEVICE_TREE="zynq-zed"
```
